
RDEPENDS_bluez5:remove = "libasound-module-bluez"
