DEPENDS:append = " virtual/libgl"

