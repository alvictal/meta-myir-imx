
COMPATIBLE_MACHINE = "(mx8)"
COMPATIBLE_MACHINE:mx8mm = "(^$)"
